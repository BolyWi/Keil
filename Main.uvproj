# Keil uVision project Main.uvproj, settings and files
target C51 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Main +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: main.c io.h
